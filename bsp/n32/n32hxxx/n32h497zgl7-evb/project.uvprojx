# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H497xG Nationstech
  pack: Nationstech.N32H49x_DFP.0.2.0
  cpu: IRAM(0x20000000,0x90000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_CM4, N32H49x, USE_STDPERIPH_DRIVER, RT_USING_LIBC, __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, RT_USING_ARMLIBC
  c include: ..\..\..\..\include;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\posix\io\poll;..\..\..\..\components\drivers\include;board\ports;..\..\..\..\components\net\utest;..\libraries\N32_Drivers;..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\components\libc\posix\io\epoll;..\libraries\N32_Drivers\drivers;..\..\..\..\components\drivers\smp_call;..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;packages\CMSIS-Core-latest\Include;packages\n32h49x_std_driver-latest\n32h49x_std_periph_driver\inc;..\..\..\..\components\libc\compilers\common\include;..\libraries\N32_Drivers\drivers\config;..\..\..\..\components\finsh;board\Cube_Config\USER\inc;applications;board;..\..\..\..\components\libc\posix\ipc;packages\n32h49x_cmsis_driver-latest\device;..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\components\drivers\include;applications\test_file;..\..\..\..\libcpu\arm\common;.;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\libcpu\arm\cortex-m4
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x90000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    ../libraries/N32_Drivers/drivers/: drv_gpio.c drv_usart.c
    ../libraries/N32_Drivers/: drv_common.c
    board/Cube_Config/USER/src/: n32h49x_cfg.c
    board/: board.c
  group Finsh
    ../../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/n32h49x_std_driver-latest/n32h49x_std_periph_driver/src/: misc.c n32h49x_gpio.c n32h49x_dma.c n32h49x_pwr.c n32h49x_rcc.c n32h49x_dbg.c n32h49x_exti.c n32h49x_flash.c n32h49x_usart.c
  group Libraries-CMSIS
    packages/n32h49x_cmsis_driver-latest/device/: system_n32h49x.c
    packages/n32h49x_cmsis_driver-latest/device/startup/: startup_n32h49x.s
